# Keil uVision project LAB_009.uvprojx, settings and files
target NXP LPC4088 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_009
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group Library
    ./Library/: GPIO.c Wait.c Timer.c SystemStructures.h
    ./: Led.h Led.c PWM.h PWM.c Motor.c Motor.h Car.c Car.h ADC.h ADC.c LDR.c LDR.h HM10.h HM10.c External.h External.c Potentiometer.c Potentiometer.h Timer.h Ultrasonic.c Ultrasonic.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
